# Keil uVision project GPIO.uvproj, settings and files
target SysTick (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GPIO +hex
  c flags: Optim=1
  c include: .\Source\App;.\Source\CMSIS\Core\CM3;.\Source\CMSIS\Core\CM3\startup\arm;.\Source\STM32F10x_StdPeriph_Driver\inc;.\Source\STM32F10x_StdPeriph_Driver\src;C:\Keil\ARM\INC\ST\STM32F10xx
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./Source/CMSIS/Core/CM3/: core_cm3.c
    ./Source/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group APP
    ./Source/App/: main.c GLCD.c stm32f10x_it.c USART.c
    ./Source/CMSIS/Core/CM3/: system_stm32f10x.c
  group Picture
    ./Source/App/: bmp.c
  group LIB
    ./Source/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
